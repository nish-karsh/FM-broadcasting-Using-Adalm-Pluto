options:
  parameters:
    author: nishk
    generate_options: qt_gui
    id: fm_try
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: de_viation
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: Station
    num_opts: '3'
    option0: int(92.7E6)
    option1: int(91.1e6)
    option2: int(100.2e6)
    type: int
    value: int(92.7E6)
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '50E-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '15000'
    audio_stop: '20000'
    chan_rate: 384e3
    deviation: de_viation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '500000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Source_out"'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rf_decim
    interp: interp
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
